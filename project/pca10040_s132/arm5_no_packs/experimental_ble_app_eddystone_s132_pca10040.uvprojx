# Keil uVision project experimental_ble_app_eddystone_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_RTT=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 BOARD_PCA10040 DEBUG
  c misc: --c99
  c include: ..\config\experimental_ble_app_eddystone_s132_pca10040;..\config;..\..\..\sdk_components\ble\common;..\..\..\sdk_components\drivers_ext\segger_rtt;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\config;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\uart;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\softdevice\s132\headers;..\..\..\sdk_components\softdevice\s132\headers\nrf52;..\..\..\sdk_components\toolchain;..\..\..\include\ble_services;..\..\..\include\modules;..\..\..\include\def;..\..\..\include\config;..\..\..\sdk_components\ble\ble_advertising;..\..\..\sdk_components\libraries\trace;..\..\..\sdk_components\drivers_nrf\pstorage;..\..\..\include\util;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\fstorage;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\source\crypto_libs\cifra;..\..\..\source\crypto_libs\rfc6234;..\..\..\source\crypto_libs\;..\..\..\sdk_components\libraries\fstorage\config;..\..\..\sdk_external\segger_rtt;..\..\..\bsp
  asm define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20001fe8 size 0xe018
  group Application
    ../: main.c
  group Board Support
    ../../../bsp/: bsp.c
  group nRF_BLE
    ../../../sdk_components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../sdk_components/ble/ble_advertising/: ble_advertising.c
  group nRF_Drivers
    ../../../sdk_components/libraries/uart/: app_uart.c
    ../../../sdk_components/drivers_nrf/delay/: nrf_delay.c
    ../../../sdk_components/drivers_nrf/common/: nrf_drv_common.c
    ../../../sdk_components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../sdk_components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../sdk_components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../sdk_components/libraries/button/: app_button.c
    ../../../sdk_components/libraries/util/: app_error.c nrf_assert.c nrf_log.c app_error_weak.c app_util_platform.c
    ../../../sdk_components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../sdk_components/libraries/uart/: retarget.c
    ../../../sdk_components/libraries/scheduler/: app_scheduler.c
    ../../../sdk_components/libraries/fstorage/: fstorage.c
    ../../../sdk_external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../sdk_components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../../../sdk_components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group BLE_Services
    ../../../source/ble_services/: ble_ecs.c
  group Modules
    ../../../source/modules/: eddystone_ble_handler.c eddystone_adv_slot.c eddystone_security.c eddystone_registration_ui.c eddystone_flash.c eddystone_advertising_manager.c eddystone_tlm_manager.c
  group cifra
    ../../../source/crypto_libs/cifra/: blockwise.c cbcmac.c chash.c cmac.c curve25519.donna.c drbg.c eax.c gf128.c hmac.c modes.c sha1.c sha256.c aes.c
  group rfc6234
    ../../../source/crypto_libs/rfc6234/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group tiny-aes128-c
    ../../../source/crypto_libs/tiny-aes128-c/: aes.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
